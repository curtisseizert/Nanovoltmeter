# Keil uVision project NVM_RevB.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32U575RITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: NVM_RevB
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=7 wLevel=1
  c include: .\include;..\..\..\..\AppData\Local\Arm\Packs\ARM\CMSIS\5.9.0\CMSIS\Core\Include;..\..\..\..\AppData\Local\Arm\Packs\Keil\STM32U5xx_DFP\2.2.0\Drivers\CMSIS\Device\ST\STM32U5xx\Include;..\..\..\..\AppData\Local\Arm\Packs\Keil\STM32U5xx_DFP\2.2.0\CMSIS\Zone\stm32u575xx
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  scatter file: .\RTE\Device\STM32U575RITxQ\stm32u575xx_flash.sct
  group src
    ./src/: ad403x.c ad5686.c adc.c delay.c gpio.c it.c main.c ospi.c spi.c sys_cfg.c tim.c uart.c dac.c dma.c i2c.c tmp117.c acq.c serial_io.c
  group include
    ./include/: ad403x.h ad5686.h adc.h gpio.h it.h main.h ospi.h spi.h sys_cfg.h tim.h uart.h dac.h dma.h i2c.h tmp117.h acq.h serial_io.h
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.0
