# Keil uVision project NVM_RevB_2.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32U575RITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: NVM_RevB_2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=7
  c misc: -Wall -Wpedantic
  c include: .\include;..\..\..\..\AppData\Local\Arm\Packs\Keil\STM32U5xx_DFP\2.2.0\Drivers\CMSIS\Device\ST\STM32U5xx\Include;..\..\..\..\AppData\Local\Arm\Packs\ARM\CMSIS\5.9.0\CMSIS\Core\Include;..\..\..\..\AppData\Local\Arm\Packs\Keil\STM32U5xx_DFP\2.2.0\CMSIS\Zone\stm32u575xx
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  scatter file: ..\PrecisionSource\RTE\Device\STM32U575RITx\stm32u575xx_flash.sct
  group Source Group 1
    ./src/: acq.c ad403x.c ad5686.c adc.c cmd_handler.c dac.c dma.c fifo.c gpio.c i2c.c lexer.c main.c nvmb.c serial_io.c sinc.c spi.c sys_cfg.c tim.c tmp117.c uart.c
    ./include/: acq.h acq_private.h ad403x.h ad5686.h adc.h cmd_handler.h dac.h dma.h fifo.h gpio.h i2c.h lexer.h main.h nvmb.h serial_io.h sinc.h spi.h sys_cfg.h tim.h tmp117.h uart.h
software components: CMSIS:CORE 6.0.0, Device:Startup 1.3.0
